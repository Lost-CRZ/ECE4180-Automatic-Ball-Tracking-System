# Keil uVision project ECE.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ECE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Library;.\blocks\header;.\blocks\source;.\Start;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ./Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group blocks
    ./blocks/header/: Camera.h Delay.h Filter.h GPIOSection_Init.h LED.h OLED.h OLED_Font.h PID.h PWM.h Servo.h Timer.h ADC.h
    ./blocks/source/: Camera.c Delay.c Filter.c GPIOSection_Init.c LED.c OLED.c PID.c PWM.c Servo.c Timer.c ADC.c
  group user
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.0
